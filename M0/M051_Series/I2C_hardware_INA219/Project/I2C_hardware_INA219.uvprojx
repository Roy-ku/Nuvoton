# Keil uVision project I2C_hardware_INA219.uvprojx, settings and files
target I2C_simulation_INA219 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: M058LDN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: M051 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\Library\Device\Nuvoton\M051Series\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\External
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Main
    ../USER/: Main.c
  group Library
    ../../../../Library/StdDriver/src/: adc.c clk.c gpio.c pwm.c timer.c uart.c i2c.c
  group External
    ../External/: User_Delay.c GPIO_I2C.c INA219_hardware_Driver.c
software components: CMSIS:CORE 5.1.2, Device:Startup 0.00.001
